Commit message: Add files via upload

File: sr80_moveit_config_new/config/gazebo_SR80.urdf (robot description, URDF)
Before this commit: robot SR80, 11 links, 10 joints
Links:
- removed link world
Joints:
- removed joint world-base_link-fixed
